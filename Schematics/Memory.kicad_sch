File: Schematics/Memory.kicad_sch (KiCad schematic)
At the start: 2 parts, among them IC1 FM25V02A-GTR

Commit message: WIP
Other:
- moved on the sheet: C1401, IC1
